# Keil uVision project codigo.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: codigo
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: Delay.cpp Delay.h I2C.cpp I2C.h LcdI2c.cpp LcdI2c.h main.cpp Acelerometro.cpp Acelerometro.h GY-271.cpp GY-271.h
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0, Device:Startup 2.6.3
