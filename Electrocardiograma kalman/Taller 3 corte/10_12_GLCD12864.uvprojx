# Keil uVision project 10_12_GLCD12864.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 10_10_GLCD12864 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: HSE_VALUE=8000000
  c include: .\Lib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: Main.cpp
    ./Lib/: Delay.cpp Delay.h FontTexto.h GLcd.cpp GLcd.h GLcd12864.cpp GLcd12864.h Pines.cpp Pines.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
